# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\USART;..\HARDWARE\DELAY;..\HARDWARE\SYS;..\HARDWARE\LCD;..\APP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\STM32F10x_DSP_Lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/LED/: bsp_led.c
    ../HARDWARE/KEY/: bsp_key.c
    ../HARDWARE/EXTI/: bsp_exti.c
    ../HARDWARE/TIMER/: bsp_timer.c
    ../HARDWARE/USART/: bsp_usart.c
    ../HARDWARE/DELAY/: bsp_delay.c
    ../HARDWARE/SYS/: bsp_sys.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: bsp_adc.c
    ../HARDWARE/DAC/: bsp_dac.c
  group APP
    ../APP/: osc_ui.c
  group DSP
    ../STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
    ../STM32F10x_DSP_Lib/src/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
